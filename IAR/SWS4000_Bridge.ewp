# IAR project SWS4000_Bridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SYSCLK_FREQ_72MHz; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CODE\ucos_core; ..\CODE\ucos_port; ..\CODE\task; ..\CODE\global; ..\CODE\drive; ..\CODE\tinySH; ..\CODE\sh_nodes; ..\CODE\libraries; ..\CODE\stm32_lib; ..\CODE\module; ..\CODE\command
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: SWS4000_Bridge.bin
  ILINK.IlinkOutputFile: SWS4000_Bridge.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group boot
    ../CODE/boot/: init.c main.c
  group command
    ../CODE/command/: cbus_cmd.c command.c dbus_cmd.c
  group document
    ../DOC/: 修改记录.txt 模板.code 模板.head 编码规范.txt
  group drive/high_drive
    ../CODE/drive/: cbus.c crc16.c dbus.c io.c spibus.c spin_lock.c stream.c
  group drive/low_drive
    ../CODE/global/: asm_code.c
    ../CODE/drive/: button.c buzzer.c delay.c interrupt.c led.c spi.c usart.c watchdog.c
  group drive/stm32_lib
    ../CODE/stm32_lib/: core_cm3.c misc.c startup_stm32f10x_md_iar.s stm32f10x.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c system_stm32f10x.c
  group global
    ../CODE/global/: app_hook.c global.c utility.c
  group module
    ../CODE/module/: div.c hep.c hot.c phq.c pump.c py.c ufp.c
  group tasks
    ../CODE/task/: stack.c task_feeddog.c task_heartBeat.c task_led.c task_start.c
  group timer
    ../CODE/timer/: tmr_clock.c tmr_scanKey.c tmr_warnFlash.c
  group tinySH/core
    ../CODE/tinySH/: shell.c shell_code.c shell_nodes.c
  group tinySH/nodes
    ../CODE/sh_nodes/: sh_debug.c sh_div.c sh_hot.c sh_phq.c sh_py.c sh_root.c sh_sbin.c sh_test.c sh_tool.c
  group ucos_core
    ../CODE/ucos_core/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C os_tmr.c
  group ucos_port
    ../CODE/ucos_port/: os_cpu_a_iar.asm os_cpu_c.c
