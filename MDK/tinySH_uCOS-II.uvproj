# Keil uVision project tinySH_uCOS-II.uvproj, settings and files
target tinySH uCOS-II (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tinySH uCOS-II +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,SYSCLK_FREQ_72MHz,STM32F10X_MD
  c include: ..\CODE\drive;..\CODE\stm32_lib;..\CODE\global;..\CODE\ucos_port;..\CODE\ucos_core;..\CODE\tinySH;..\CODE\task;..\CODE\command;..\CODE\module
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32_lib
    ../CODE/stm32_lib/: core_cm3.c misc.c stm32f10x.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c startup_stm32f10x_md_arm.s stm32f10x_gpio.c
  group periph_drive
    ../CODE/drive/: stream.c spin_lock.c interrupt.c delay.c usart.c watchdog.c
    ../CODE/global/: asm_code.c
  group global
    ../CODE/global/: global.c utility.c app_hook.c
  group boot
    ../CODE/boot/: init.c main.c
  group ucos_port
    ../CODE/ucos_port/: os_cpu_c.c os_cpu_a_arm.asm
  group ucos_core
    ../CODE/ucos_core/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C os_tmr.c
  group task
    ../CODE/task/: task_start.c task_feeddog.c stack.c
  group tinySH
    ../CODE/tinySH/: shell.c shell_code.c shell_nodes.c
  group sh_nodes
    ../CODE/sh_nodes/: sh_root.c sh_sbin.c sh_debug.c
  group document
    ../DOC/: 编码规范.txt 模板.code 模板.head 修改记录.txt
